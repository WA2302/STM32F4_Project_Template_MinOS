# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --C99 --cpp
  c include: ../;../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../MinOS;../App;../../../Public
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\Output\Project.sct
  group App
    ../: stm32f4xx_it.c main.c
    ../App/: App_include.h App_Demo1.c App_Demo2.c App_Demo3.c
  group Public
    ../../../Public/: Pub_Include.h Pub_CPID_Delta.cpp Pub_CSoftPWM.cpp Pub_CTimer.cpp
  group MinOS
    ../../../MinOS/: minos.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_flash.c stm32f4xx_dma2d.c stm32f4xx_pwr.c stm32f4xx_wwdg.c stm32f4xx_fmpi2c.c stm32f4xx_spi.c stm32f4xx_hash.c stm32f4xx_ltdc.c stm32f4xx_dfsdm.c stm32f4xx_dbgmcu.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_iwdg.c stm32f4xx_cryp.c stm32f4xx_flash_ramfunc.c stm32f4xx_rtc.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_aes.c stm32f4xx_adc.c stm32f4xx_cec.c stm32f4xx_cryp_des.c stm32f4xx_i2c.c stm32f4xx_spdifrx.c stm32f4xx_usart.c stm32f4xx_sai.c stm32f4xx_crc.c stm32f4xx_rng.c misc.c stm32f4xx_fsmc.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_dac.c stm32f4xx_lptim.c stm32f4xx_can.c stm32f4xx_dcmi.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_hash_md5.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_hash_sha1.c stm32f4xx_fmc.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427_437xx.s startup_stm32f469_479xx.s startup_stm32f411xe.s startup_stm32f446xx.s startup_stm32f412xg.s startup_stm32f401xx.s startup_stm32f410xx.s startup_stm32f40_41xxx.s startup_stm32f413_423xx.s startup_stm32f429_439xx.s
  group Doc
    ../: README.md
software components: CMSIS:CORE 5.2.0
